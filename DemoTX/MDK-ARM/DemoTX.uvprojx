# Keil uVision project DemoTX.uvprojx, settings and files
target DemoTX (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32WL55JCIx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.1
  cpu: IRAM(0x20000000-0x20003FFF) IRAM2(0x20008000-0x2000BFFF) IROM(0x8000000-0x801FFFF)  CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: DemoTX +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WL55xx
  c include: ../Core/Inc; ../Drivers/STM32WLxx_HAL_Driver/Inc; ../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../Drivers/CMSIS/Include; ..\UsrApp; ../Utilities/trace/adv_trace; ../Utilities/misc; ../Utilities/sequencer; ../Utilities/timer; ../Utilities/lpm/tiny_lpm; ../Middlewares/Third_Party/SubGHz_Phy; ../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;../SubGHz_Phy/App;../SubGHz_Phy/Target
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20008000 size 0x4000
  scatter file: stm32wl55xx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dac.c dma.c rtc.c subghz.c stm32_lpm_if.c sys_app.c timer_if.c stm32_adv_trace_if.c board_resources.c tim.c usart.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Drivers/STM32WLxx_HAL_Driver
    ../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_dac.c stm32wlxx_hal_dac_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group UsrApp
    ../UsrApp/: debug.c adc_app.c dac_app.c
  group Application/User/SubGHz_Phy/App
    ../SubGHz_Phy/App/: app_subghz_phy.c subghz_phy_app.c
  group Application/User/SubGHz_Phy/Target
    ../SubGHz_Phy/Target/: radio_board_if.c
  group Middlewares/SubGHz_Phy
    ../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio.c radio_driver.c
  group Utilities
    ../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../Utilities/sequencer/: stm32_seq.c
    ../Utilities/timer/: stm32_timer.c
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 5.4.0
